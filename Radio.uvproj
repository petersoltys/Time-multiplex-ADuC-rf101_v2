# Keil uVision project Radio.uvproj, settings and files
target Master (5060020::V5.06 (build 20)::ARMCC)
  device: ADuCRF101 Analog Devices
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: Radio +hex
  AfterMake: $P\Revision_control\rev.bat
  AfterMake: $P\Integrity\Integrity.bat #H
  c flags: Optim=1
  c include: $K\ARM\CMSIS\Include;.\src\include\Common;.\src\include\DasLib;.\Integrity
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ./src/: Slave.c settings.h Master.c
  group Common
    ./src/include/Common/RealView/: Retarget.c startup_ADuCRF101.s
    ./src/include/Common/: radioeng.c system_ADuCRF101.c
  group Libraries
    ./src/include/DasLib/: AdcLib.c ClkLib.c DioLib.c DmaLib.c FeeLib.c GptLib.c I2cLib.c IntLib.c PwmLib.c PwrLib.c RstLib.c SpiLib.c UrtLib.c WdtLib.c WutLib.c
    ./Integrity/: crc.c
target Slave (5060020::V5.06 (build 20)::ARMCC)
  device: ADuCRF101 Analog Devices
  cpu: as above
  output: Radio +hex
  AfterMake: $P\Revision_control\rev.bat
  AfterMake: $P\Integrity\Integrity.bat #H
  c flags: Optim=1 oTime=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
